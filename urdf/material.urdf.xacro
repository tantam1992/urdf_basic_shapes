Commit message: fix gray color rviz

File: urdf/material.urdf.xacro (robot description, xacro)
@@ -16,5 +16,5 @@
     <color rgba="1 1 1 1"/>
   </material>
-  <material name="Grey">
+  <material name="Gray">
     <color rgba="0.8 0.8 0.8 1"/>
   </material>
